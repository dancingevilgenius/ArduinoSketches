#include "Arduino_LED_Matrix.h"
#include <Wire.h>
#include "SparkFun_Qwiic_Joystick_Arduino_Library.h" //Click here to get the library: http://librarymanager/All#SparkFun_joystick

JOYSTICK joystick; //Create instance of this object
ArduinoLEDMatrix matrix;




uint8_t blank[8][12] = {
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 }
};

uint8_t error[8][12] = {
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 1, 1, 1, 0, 1, 1, 0, 0, 1, 1, 0, 0 },
  { 1, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0 },
  { 1, 1, 1, 0, 1, 1, 0, 0, 1, 1, 0, 0 },
  { 1, 0, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0 },
  { 1, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0 },
  { 1, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 }
};



uint8_t center_dot[8][12] = {
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 1, 1, 1, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 1, 1, 1, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 1, 1, 1, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 }
};



uint8_t north[8][12] = {
  { 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 1, 1, 1, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 }
};

uint8_t south[8][12] = {
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 1, 1, 1, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0 }
};


uint8_t east[8][12] = {
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 }
};


uint8_t west[8][12] = {
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 }
};



uint8_t north_east[8][12] = {
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 }
};


uint8_t south_east[8][12] = {
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1 }
};


uint8_t north_west[8][12] = {
  { 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 }
};


uint8_t south_west[8][12] = {
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 },
  { 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0 }
};


void setup() {
  
  Serial.begin(9600);

  Wire1.begin();

  initMatrix();

  initJoystick();
}


void initJoystick(){
  if(joystick.begin(Wire1) == false)
  {
    Serial.println("Joystick does not appear to be connected. Please check wiring. Freezing...");
    matrix.renderBitmap(error, 8, 12);    
    while(1);
  } else {
    Serial.println("Joystick initialized.");
  }
}

void initMatrix(){
  matrix.begin();
}






void loop(){

  //clockwiseArrows();
  readJoystick();

}

void readJoystick(){

  // Clear the screen
  matrix.renderBitmap(blank, 8, 12);

    int X = joystick.getHorizontal();
    int Y = joystick.getVertical();
    int B = joystick.getButton();

    String east_west = "";
    String north_south = "";

    if  (X > 700)
    {
        Serial.println("W");
        east_west = "W";
        matrix.renderBitmap(west, 8, 12);    
    }
    else if (X < 300)
    {      
        Serial.println("E");
        east_west = "E";
        matrix.renderBitmap(east, 8, 12);    
    } 

    if  (Y > 700)
    {
        Serial.println("N");
        north_south="N";
        matrix.renderBitmap(north, 8, 12);    
    }
    else if (Y < 300)
    {
        Serial.println("S");
        north_south = "S";
        matrix.renderBitmap(south, 8, 12);    
    }


    if(east_west == "E"){

      if(north_south == "N"){
        matrix.renderBitmap(north_east, 8, 12);    
      } else if (north_south == "S"){
        matrix.renderBitmap(south_east, 8, 12);    
      } else {
        matrix.renderBitmap(east, 8, 12);    
      }

    } else if(east_west == "W"){
      if(north_south == "N"){
        matrix.renderBitmap(north_west, 8, 12);    
      } else if (north_south == "S"){
        matrix.renderBitmap(south_west, 8, 12);    
      } else {
        matrix.renderBitmap(west, 8, 12);    
      }
    } else if (north_south == "N"){
      matrix.renderBitmap(north, 8, 12);    
    } else if (north_south == "S") {
      matrix.renderBitmap(south, 8, 12);    
    }



    if (B == 0)
    {
        Serial.println("Button");
        matrix.renderBitmap(center_dot, 8, 12);    
    }


  delay(200);





  delay(200);

}



void clockwiseArrows(){
// Blank
delay(1000);
matrix.renderBitmap(blank, 8, 12);




delay(1000);
matrix.renderBitmap(north, 8, 12);


delay(1000);
matrix.renderBitmap(north_east, 8, 12);


delay(1000);
matrix.renderBitmap(east, 8, 12);


delay(1000);
matrix.renderBitmap(south_east, 8, 12);

delay(1000);
matrix.renderBitmap(south, 8, 12);


delay(1000);
matrix.renderBitmap(south_west, 8, 12);


delay(1000);
matrix.renderBitmap(west, 8, 12);


delay(1000);
matrix.renderBitmap(north_west, 8, 12);


}
